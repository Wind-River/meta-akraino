REQUIRED_DISTRO_FEATURES_remove = "x11 opengl"
PACKAGES_remove = "packagegroup-self-hosted-graphics"
RDEPENDS_packagegroup-self-hosted_remove = "packagegroup-self-hosted-graphics"
RDEPENDS_packagegroup-self-hosted-extended_remove = "settings-daemon"
