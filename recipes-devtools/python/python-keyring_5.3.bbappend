DEPENDS += " python-hgtools-native"
