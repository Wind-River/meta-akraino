require wrlinux-ovp/recipes-devtools/qemu/qemu-ovp-3.0.0.inc
